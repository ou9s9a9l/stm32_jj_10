# Keil uVision project can2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can2
  AfterMake: fromelf.exe   --bin   -o   "$L@L.bin"   "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: .\USER;.\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group user
    ./USER/: can.c led.c stm32f10x_it.c bsp_spi_nrf.c bsp_usart1.c bsp_TiMbase.c stm32f10x_conf.h judge.c search.c bsp_usart3.c stm_flash.c
  group fwlib
    ./FWlib/src/: misc.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_flash.c
  group rf
    ./USER/: sx1276-LoRa.c Delay.c rf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
