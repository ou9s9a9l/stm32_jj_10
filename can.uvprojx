# Keil uVision project can.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\USER;.\FWlib\inc;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c 111.c
  group New Group
    ./USER/: can.c led.c usart1.c stm32f10x_it.c
  group fwlib
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_can.c
  group cmsis
    ./CMSIS/: core_cm3.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
